# Repository aitesam961/RP2040-Devkit

File README.md:

# RP2040-Devkit 
This is a development board embedding a very popular RP2040 Microcontroller developed by Raspberry Pi Foundation. The idea is to design a very basic set of hardware for people getting started with RP2040 who just need a custom Board other than RP2040 Pico or if they want to design their own.

The RP2040 is supported with both C/C++ and MicroPython cross-platform development environments, including easy access to runtime debugging. It has UF2 boot and floating-point routines baked into the chip. The built-in USB can act as both device and host. It has two symmetric cores and high internal bandwidth, making it useful for signal processing and video. While the chip has a large amount of internal RAM, the board includes an additional 16MB external QSPI flash chip to store program code.

More About RP2040 Could be found here: [RP2040](https://www.raspberrypi.com/documentation/microcontrollers/rp2040.html)

#### Some Highlights about RP2040 Before we go Ahead

## Features:
* [ ] RP2040 Processor
* [ ] Raspberry PI silicon MCU
* [ ] Capable of handling python Codes
* [ ] USB-C for power
* [ ] On-Board Serial Wire Debug
* [ ] GPIO pins extended to 2.54mm pitch Headers
* [ ] Convenient for soldering on Boards
* [ ] Easy To flash directly through VS or Arduino IDE
* [ ] Low Power consumption
* [ ] Cost effective design
* [ ] Small Size. Perfect for tight Fit projects

## What's Special About it!!

The RP2040 utilizes dual ARM Cortex-M0+ processors (up to 133MHz) and features:
- 264kB of embedded SRAM in six banks
- Six dedicated IO for SPI Flash (supporting XIP)

## Connectivity
- 30 multifunction GPIO
- Dedicated hardware for commonly used peripherals
- Programmable IO for extended peripheral support
- Four channel ADC with internal temperature sensor, 0.5 MSa/s, 12-bit conversion
- USB 1.1 Host/Device

> **Note:** The GPIO pins are muxed so you can reconfigure the pins for the digital interface of your choice! Check out the RP2040 datasheet for more information on the pins that are broken out on the board.

=== Software Development

https://datasheets.raspberrypi.com/pico/raspberry-pi-pico-c-sdk.pdf[Raspberry Pi Pico C/{cpp} SDK]:: Libraries and tools for C/C++ development on RP2040 microcontrollers

https://datasheets.raspberrypi.com/pico/raspberry-pi-pico-python-sdk.pdf[Raspberry Pi Pico Python SDK]:: A MicroPython environment for RP2040 microcontrollers

The API level Doxygen documentation for the Raspberry Pi Pico C/{cpp} SDK is also available https://rptl.io/pico-doxygen[as a micro-site].

## Contributions

Contributions are what make the open source community such an amazing place to learn, inspire, and create. Any contributions you make are **greatly appreciated**.

If you have a suggestion that would make this better, please fork the repo and create a pull request. You can also simply open an issue with the tag "enhancement".
Don't forget to give the project a star! Thanks again!

1. Fork the Project
2. Create your Feature Branch (`git checkout -b feature/AmazingFeature`)
3. Commit your Changes (`git commit -m 'Add some AmazingFeature'`)
4. Push to the Branch (`git push origin feature/AmazingFeature`)
5. Open a Pull Request

> [NOTE]
If you are building applications with the C/C++ SDK and targeting boards other than the Raspberry Pi Pico, you will need to pass `-DPICO_BOARD=boardname` to CMake. Here `boardname` is the name of your board, e.g. for the Adafruit Feather RP2040 you should pass `-DPICO_BOARD=adafruit_feather_rp2040`. See the https://github.com/raspberrypi/pico-sdk/tree/master/src/boards[`boards/` directory] in the Pico SDK, and the https://forums.raspberrypi.com/viewtopic.php?f=147&t=304393[forums], for more information.

For More Information, refer to The [Datasheet](https://datasheets.raspberrypi.com/pico/pico-datasheet.pdf)

## License

Distributed under the MIT License. See `LICENSE.txt` for more information.

<p align="right">(<a href="#top">back to top</a>)</p>

## EAGLE design Hardware/SparkFun_ProMicro-RP2040.brd

Board: 4 copper layers, 17.4 x 32.6 mm, 109 parts (39 on the bottom side), 49 nets.

Parts:
C6: 1.0uF; 0402-TIGHT
C7, C8: 10uF; 0402-TIGHT
C9, C12, C14, C15, C16, C17, C18, C19, C29: 0.1uF; 0402-TIGHT
C11, C13: 15pF; 0402-TIGHT
C20, C21, C22, C23: 2.2uF; 0402-TIGHT
D2: 3A/10V/280mV; SOD-323
F1: 6V 0.5A; 0805
FRAME2: FRAME-LEDGER; CREATIVE_COMMONS
J2: Qwiic; JST04_1MM_RA
J3, J4: 1X12_CASTELLATED
J5: USB Female Type C Connector; USB-C-16P_4LAYER-PADS
JP1, JP2: FIDUCIAL1X2; FIDUCIAL-1X2
JP14: USB_SOLDER_PADS; USB-SOLDER-PADS
LED1: RED; LED-0603
LOGO1: SFE_LOGO_NAME_FLAME.1_INCH; SFE_LOGO_NAME_FLAME_.1
LOGO3: QWIIC_LOGO_6MM; QWIIC_6MM
LOGO4: SFE_LOGO_FLAME.1_INCH; SFE_LOGO_FLAME_.1
LOGO5: SPECIAL_INSTRUCTIONS-ORDERING; ORDERING_INSTRUCTIONS
R1, R3: 5.1k; 0402-TIGHT
R2, R16: 10k; 0402-TIGHT
R5, R7: 2.2k; 0402-TIGHT
R10, R11, R15: 1k; 0402-TIGHT
R12, R13: 27; 0402-TIGHT
R14: 200; 0402-TIGHT
S1: Reset; TACTILE_SWITCH_SMD_4.6X2.8MM
S2: Boot; TACTILE_SWITCH_SMD_4.6X2.8MM
TP1, TP2, TP3: PAD.03X.05
U1: 3.3V; SOT23-5
U2: RP2040; QFN-56
U3: WS2812-2020
U4: W25QXX128MBIT; WSON-8-6X5-SKINNY_CENTERPAD
U$1, U$11: A00
U$2: GND_0
U$3: OSHW-LOGOMINI; OSHW-LOGO-MINI
U$4: PRO_MICRO0
U$5: #0
U$6: 70
U$7: 81
U$8: 92
U$9, U$64: CI4
U$10, U$67: SCK3
U$12, U$20: A10
U$13, U$33: A21
U$14, U$39: A32
U$15, U$22, U$74: GND2
U$16: 3V3_0
U$17: RAW0
U$18: C0
U$19, U$76: TX0
U$21, U$75: RX1
U$23, U$53: 20
U$24, U$54: 31
U$25, U$55: 42
U$26, U$56: 53
U$27, U$57: 64
U$28: D#1
U$29: D#2
U$30: G0
U$31: V3
U$32: 210
U$34: #RST#0
U$35: D1
U$36: B0
U$37: R0
U$38: RP20401
U$40: DO0
U$66: CO5
U$68: #RST#1
U$69: 3V30
U$73: PWR0
Y1: 12MHz; CRYSTAL-SMD-2X2.5MM

Connections:
0/TX0: J3.12, J3.12B, U2.2
1.1V: C18.1, C19.1, C20.1, U2.23, U2.45, U2.50
1/RX0: J3.11, J3.11B, U2.3
2: J3.8, J3.8B, U2.4
3: J3.7, J3.7B, U2.5
3.3V: C8.2, C9.1, C12.1, C14.1, C15.1, C16.1, C17.1, C21.1, C23.1, C29.1, J2.2, J4.4, J4.4B, R2.2, R5.2, R7.2, R11.2, R14.2, R16.2, U1.5, U2.1, U2.10, U2.22, U2.33, U2.42, U2.44, U2.48, U2.49, U4.8
4: J3.6, J3.6B, U2.6
5: J3.5, J3.5B, U2.7
6: J3.4, J3.4B, U2.8
7: J3.3, J3.3B, U2.9
8/TX1: J3.2, J3.2B, U2.11
9/RX1: J3.1, J3.1B, U2.12
16/SDA: J2.3, R5.1, U2.27
17/SCL: J2.4, R7.1, U2.28
20/SPI_CIPO: J4.10, J4.10B, U2.31
21/SPI_!CS!: J4.12, J4.12B, U2.32
22/SPI_SCK: J4.9, J4.9B, U2.34
23/SPI_COPI: J4.11, J4.11B, U2.35
25/WS2812-DI: U2.37, U3.3
!RESET!: J4.3, J4.3B, R2.1, S1.3, S1.4, U2.26
A0: J4.8, J4.8B, U2.38
A1: J4.7, J4.7B, U2.39
A2: J4.6, J4.6B, U2.40
A3: J4.5, J4.5B, U2.41
ADC_VDD: C22.1, R14.1, U2.43
BOOT: R15.2, S2.3, S2.4
GND: C6.1, C7.1, C8.1, C9.2, C11.1, C12.2, C13.1, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C29.2, J2.1, J3.9, J3.9B, J3.10, J3.10B, J4.2, J4.2B, J5.GND, J5.GND2, JP14.GND, LED1.C, R1.1, R3.1, S1.1, S1.2, S2.1, S2.2, U1.2, U2.19, U2.EPAD, U3.2, U4.4
unnamed: TP3.P$1, U3.1
unnamed: J5.A5, R3.2
unnamed: J5.B5, R1.2
unnamed: LED1.A, R11.1
QSPI-0: U2.53, U4.5
QSPI-1: U2.55, U4.2
QSPI-2: U2.54, U4.3
QSPI-3: U2.51, U4.7
QSPI-CLK: U2.52, U4.6
QSPI-CS: R15.1, R16.1, U2.56, U4.1
RAW: C7.2, D2.C, J4.1, J4.1B, U1.1, U1.3, U3.4
RP_D1+: R13.2, U2.47
RP_D1-: R12.2, U2.46
RP_D+: J5.A6, J5.B6, JP14.D+, R13.1
RP_D-: J5.A7, J5.B7, JP14.D-, R12.1
SWDCK: TP1.P$1, U2.24
SWDIO: TP2.P$1, U2.25
USB_RAW: D2.A, F1.2
V_USB: C6.2, F1.1, J5.VBUS1, J5.VBUS2, JP14.VBUS
X1A: R10.2, U2.21
X1B: C11.2, R10.1, Y1.P1
X2: C13.2, U2.20, Y1.P3

## Commit log

2022-03-03 Create Documents
2022-03-03 Uploaded Gerber

Notices in the files:
parts and their libraries:
SparkFun-Aesthetics: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
SparkFun-Aesthetics: Released under the Creative Commons Attribution Share-Alike 4.0 License
SparkFun-Aesthetics: https://creativecommons.org/licenses/by-sa/4.0
